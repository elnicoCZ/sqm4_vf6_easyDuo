# IAR project easyDuo_sqm4vf6_eb_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: MVF61GS151MK50_M4 Freescale MVF61GS151MK50_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\bsp; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\psp; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\bsp\Generated_Code; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\mfs; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\ffs; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\mcc; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\rtcs; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug; ..\..; ..\..\libesl; ..\..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\bsp; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\psp; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\bsp\Generated_Code; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\mcc; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug; ..\..; ..\..\libesl
  OBJCOPY.OOCOutputFile: easyDuo_sqm4vf6_eb_m4.bin
  ILINK.IlinkOutputFile: easyDuo_sqm4vf6_eb_m4.out
  ILINK.IlinkIcfFile: ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\bsp\bsp.a; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\psp\psp.a; $_MQX_PATH_$\lib\sqm4vf6_eb_m4.iar\debug\mcc\mcc.a; ..\..\libesl\libesld_sqm4vf6_eb_m4.a
  ILINK.IlinkProgramEntryLabel: __boot
  group Source
    ../../: accelerometer.c accelerometer.h esl_config.h gpio.c gpio.h i2cs.h main.c mcc.c mcc.h startup.c startup.h
    ../../../common/: easyduo_mcc_common.h
